# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\PETPOSITION\KN2000(01)\KAC(3A)_MainDir; E:\PETPOSITION\KN2000(01)\KAC(3A)_libSystem\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test.bin
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: test.out
  group lib
    ../../KAC(3A)_libSystem/libProcject/Debug/Exe/: lisysProject.a
  group src
    ../: bma2x2.c bma2x2_support.c EventQueue.c hwdflash.c hwdgpio.c I2C.c main.c main_rtc.c mmi_common.c Module.c Module_wifi.c ModuleProtocol.c net.c OverTimeQueue.c Pedometer.c PedoSupport.c stm8l15x_it.c uart1.c
